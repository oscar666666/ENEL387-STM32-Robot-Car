# Keil uVision project RobotCarProject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RobotCarProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./MySTM32Lib/: ADC1.c ADC1.h Clock.c Clock.h GPIO.c GPIO.h LCD.c LCD.h PWM.c PWM.h IR.c IR.h HCSR04.c HCSR04.h TCRT5000.c TCRT5000.h
    ./: main.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
